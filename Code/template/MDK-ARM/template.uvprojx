# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Hardware;../System;../App;../USB_DEVICE/App;../USB_DEVICE/Target
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\uart5-memory.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Hardware
    ../Hardware/: motor_bus.c motor_bus.h w25q128.c Emm_V5.c Emm_V5.h key.c key.h hwt101_i2c.c hwt101_i2c.h oled.c oled.h oled_font.h Camera.c Camera.h Steer.c Steer.h QR.c QR.h tjc_screen.c tjc_screen.h lds_parser.c lds_parser.h radar_uart.c radar_uart.h
  group App
    ../App/: turntable.c turntable.h console_tx.c console_rx.c console_tx.h chassis_model.c chassis_model.h chassis_motion.c chassis_localization.c chassis_route.c chassis_route_profile.c chassis_route_profile.h chassis_motion.h chassis_observer.c chassis_observer.h chassis_telemetry.c chassis_telemetry.h hwt101_calibration.c motor_id_config.h mecanum_chassis.c mecanum_chassis.h chassis_config.h contest_screen.c contest_screen.h mechanical_arm.c mechanical_arm.h arm_console.c arm_console.h Arm.c Arm.h oled_ui.c oled_ui.h GrabTask.c grab_tracking.c GrabTask.h GrabRoute.c contest_mission.c contest_mission.h GrabRoute.h grab_calibration.c grab_calibration.h mechanical_arm_config.h radar_geometry.c radar_stability.c radar_map.c radar_map.h radar_start.c radar_start.h radar_scan.c radar_scan.h radar_console.c radar_console.h radar_host_map.c radar_host_map.h radar_host.c radar_host.h radar_host_console.c radar_host_console.h
software components: CMSIS:CORE 4.3.0
